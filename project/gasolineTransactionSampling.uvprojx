# Keil uVision project gasolineTransactionSampling.uvprojx, settings and files
target Debug (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: gasolineTransactionSampling +hex
  AfterMake: ConvertAsf2Bin.bat
  AfterMake: fromelf -c -o "$L@L.txt" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=1
  c define: STM3RF10X_HD,USE_STDPERIPH_DRIVER,DEBUG
  c misc: --diag_suppress=870
  c include: ..\usr\inc;..\bsp\inc;..\st\inc;..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\utility\inc;..\RTT
  library: MicroLIB
  memory RVCT4: ROM 0x8006800 size 0x70000
  memory RVCT9: RAM 0x20001000 size 0xf000
  group Application
    ../usr/src/: flashMgr.c main.c taxControlInterface.c uartPort.c Board.c plcMessager.c swapOrder.c gasolineTransferProtocol.c gasolineDataStore_Retrieve.c localTime.c debug.c transactionHelper.c snr.c fwVersion.c log.c ledStatus.c meterMessager.c controlledTaxSampling.c meterCPCC.c
    ../bsp/src/: bsp_rtc.c bsp_printf.c
  group Include
    ../usr/inc/: errorCode.h flashMgr.h taxControlInterface.h uartPort.h version.h board.h crc16.h plcMessager.h swapOrder.h gasolineTransferProtocol.h gasolineDataStore_Retrieve.h localTime.h transactionHelper.h snr.h fwVersion.h log.h ledStatus.h meterMessager.h controlledTaxSampling.h
    ../bsp/inc/: bsp_rtc.h
  group BSP
    ../bsp/src/: 18b20.c bsp_SST25VF016B.c bsp_timer.c bsp_usart.c bsp_i2c.c
  group ST
    ../st/src/: stm32f10x_assert.c stm32f10x_it.c
    ../st/inc/: stm32f10x_conf.h stm32f10x_it.h
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../Libraries/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c core_cm3.h
  group utility
    ../utility/inc/: Download.h
    ../utility/src/: download.c
    ../bsp/src/: common.c menu.c
  group RTT
    ../RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
software components: CMSIS:CORE 4.1.0, Device:Startup 1.0.0
